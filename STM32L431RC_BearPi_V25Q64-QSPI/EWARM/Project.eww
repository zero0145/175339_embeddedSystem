<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32L431RC_BearPi_V25Q64-QSPI.ewp</path>
  </project>
  <batchBuild />
</workspace>
